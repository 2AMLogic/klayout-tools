v {xschem version=3.4.7 file_version=1.2}
G {}
K {type=subcircuit
format="@name @pinlist @symname"
template="name=x1"}
V {}
S {}
E {}
N 100 0 200 0 {lab=X}
C {devices/ipin.sym} 100 0 0 0 {name=p1 lab=A}
C {devices/ipin.sym} 200 0 2 0 {name=p2 lab=B}
